# Keil uVision project Pocket_PowerBank.uvprojx, settings and files
target Pocket_PowerBank (6240000::V6.24::ARMCLANG)
  device: -AT32F423KCU7-4 ArteryTek
  pack: ArteryTek.AT32F423_DFP.2.1.1
  cpu: IRAM(0x20000000,0xC000) IROM(0x08000000,0x40000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: Pocket_powerBank +hex
  c flags: Optim=7 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: AT32F423KCU7_4, USE_STDPERIPH_DRIVER, AT_START_F423_V1, LV_LVGL_H_INCLUDE_SIMPLE, LV_CONF_INCLUDE_SIMPLE
  c include: ..\..\libraries\drivers\inc;..\..\libraries\cmsis\cm4\core_support;..\..\libraries\cmsis\cm4\device_support;..\inc;..\..\Bootstrap\inc;..\..\Drivers;..\..\Drivers\GC9D01;..\..\Drivers\SW6306;..\..\Drivers\SC7A20;..\..\Drivers\SD3078;..\..\Applications\LVGL;..\..\Applications\LVGL\porting;..\..\Applications\LVGL\src;..\..\Applications\LVGL\src\tick;..\..\Applications;..\..\Applications\menu;..\..\Applications\functions;..\..\Drivers\Buttons;..\..\Drivers\WLED;..\..\Applications\framework;../../middlewares/freertos/source/include;../../middlewares/freertos/source/portable/memmang;../../middlewares/freertos/source/portable/GCC/ARM_CM4F;
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0xc000
  scatter file: .\Pocket_PowerBank.sct
  group user
    ../src/: at32f423_int.c at32f423_wk_config.c main.c wk_system.c freertos_app.c include_port.c
  group bsp
    ../../Bootstrap/src/: bsp_spi.c bsp_i2c.c bsp_usart.c mini_format.c bsp_tmr.c
  group firmware
    ../../libraries/drivers/src/: at32f423_crm.c at32f423_tmr.c at32f423_gpio.c at32f423_i2c.c at32f423_usart.c at32f423_pwc.c at32f423_adc.c at32f423_spi.c at32f423_dma.c at32f423_debug.c at32f423_flash.c at32f423_crc.c at32f423_exint.c at32f423_misc.c at32f423_scfg.c
  group cmsis
    ../../libraries/cmsis/cm4/device_support/: system_at32f423.c
    ./: startup_at32f423.s
  group LVGL/porting
    ../../Applications/LVGL/porting/: lv_port_disp.c lv_port_indev.c
  group LVGL/src
    ../../Applications/LVGL/src/: lv_init.c
  group LVGL/src/core
    ../../Applications/LVGL/src/core/: lv_group.c lv_obj.c lv_obj_class.c lv_obj_draw.c lv_obj_event.c lv_obj_id_builtin.c lv_obj_pos.c lv_obj_property.c lv_obj_scroll.c lv_obj_style.c lv_obj_style_gen.c lv_obj_tree.c lv_refr.c
  group LVGL/src/display
    ../../Applications/LVGL/src/display/: lv_display.c
  group LVGL/src/draw
    ../../Applications/LVGL/src/draw/: lv_draw.c lv_draw_arc.c lv_draw_buf.c lv_draw_image.c lv_draw_label.c lv_draw_line.c lv_draw_mask.c lv_draw_rect.c lv_draw_triangle.c lv_draw_vector.c lv_image_decoder.c
    ../../Applications/LVGL/src/draw/sw/: lv_draw_sw.c lv_draw_sw_arc.c lv_draw_sw_border.c lv_draw_sw_box_shadow.c lv_draw_sw_fill.c lv_draw_sw_grad.c lv_draw_sw_img.c lv_draw_sw_letter.c lv_draw_sw_line.c lv_draw_sw_mask.c lv_draw_sw_mask_rect.c lv_draw_sw_transform.c lv_draw_sw_triangle.c lv_draw_sw_utils.c lv_draw_sw_vector.c
    ../../Applications/LVGL/src/draw/convert/: lv_draw_buf_convert.c
    ../../Applications/LVGL/src/draw/convert/neon/: lv_draw_buf_convert_neon.c
    ../../Applications/LVGL/src/draw/convert/helium/: lv_draw_buf_convert_helium.c
    ../../Applications/LVGL/src/draw/sw/blend/: lv_draw_sw_blend.c lv_draw_sw_blend_to_rgb565_swapped.c
  group LVGL/src/font
    ../../Applications/LVGL/src/font/: lv_binfont_loader.c lv_font.c lv_font_fmt_txt.c lv_font_montserrat_8.c lv_font_montserrat_10.c lv_font_montserrat_12.c lv_font_montserrat_14.c lv_font_montserrat_14_aligned.c lv_font_montserrat_16.c lv_font_montserrat_18.c lv_font_montserrat_20.c lv_font_montserrat_22.c lv_font_montserrat_24.c lv_font_montserrat_26.c lv_font_montserrat_28.c lv_font_montserrat_28_compressed.c lv_font_montserrat_30.c lv_font_montserrat_32.c lv_font_montserrat_34.c lv_font_montserrat_36.c lv_font_source_han_sans_sc_14_cjk.c lv_font_source_han_sans_sc_16_cjk.c font-terminus-u14b.c
  group LVGL/src/indev
    ../../Applications/LVGL/src/indev/: lv_indev.c lv_indev_gesture.c lv_indev_scroll.c
  group LVGL/src/layouts
    ../../Applications/LVGL/src/layouts/: lv_layout.c
    ../../Applications/LVGL/src/layouts/flex/: lv_flex.c
    ../../Applications/LVGL/src/layouts/grid/: lv_grid.c
  group LVGL/src/libs
    ../../Applications/LVGL/src/libs/barcode/: code128.c lv_barcode.c
    ../../Applications/LVGL/src/libs/bin_decoder/: lv_bin_decoder.c
    ../../Applications/LVGL/src/libs/bmp/: lv_bmp.c
    ../../Applications/LVGL/src/libs/freetype/: lv_freetype.c
  group LVGL/src/misc
    ../../Applications/LVGL/src/misc/: lv_anim.c lv_anim_timeline.c lv_area.c lv_array.c lv_async.c lv_bidi.c lv_circle_buf.c lv_color.c lv_color_op.c lv_event.c lv_fs.c lv_grad.c lv_iter.c lv_ll.c lv_log.c lv_lru.c lv_math.c lv_matrix.c lv_palette.c lv_profiler_builtin.c lv_profiler_builtin_posix.c lv_rb.c lv_style.c lv_style_gen.c lv_templ.c lv_text.c lv_text_ap.c lv_timer.c lv_tree.c lv_utils.c
    ../../Applications/LVGL/src/misc/cache/: lv_cache.c lv_cache_entry.c
    ../../Applications/LVGL/src/misc/cache/class/: lv_cache_lru_ll.c lv_cache_lru_rb.c lv_cache_sc_da.c
    ../../Applications/LVGL/src/misc/cache/instance/: lv_image_cache.c lv_image_header_cache.c
  group LVGL/src/osal
    ../../Applications/LVGL/src/osal/: lv_os.c
  group LVGL/src/others
    ../../Applications/LVGL/src/others/font_manager/: lv_font_manager.c lv_font_manager_recycle.c
    ../../Applications/LVGL/src/others/fragment/: lv_fragment.c lv_fragment_manager.c
    ../../Applications/LVGL/src/others/gridnav/: lv_gridnav.c
    ../../Applications/LVGL/src/others/ime/: lv_ime_pinyin.c
    ../../Applications/LVGL/src/others/imgfont/: lv_imgfont.c
    ../../Applications/LVGL/src/others/monkey/: lv_monkey.c
    ../../Applications/LVGL/src/others/observer/: lv_observer.c
    ../../Applications/LVGL/src/others/snapshot/: lv_snapshot.c
    ../../Applications/LVGL/src/others/sysmon/: lv_sysmon.c
    ../../Applications/LVGL/src/others/test/: lv_test_helpers.c lv_test_indev.c lv_test_indev_gesture.c lv_test_screenshot_compare.c
    ../../Applications/LVGL/src/others/translation/: lv_translation.c
    ../../Applications/LVGL/src/others/vg_lite_tvg/: vg_lite_matrix.c
    ../../Applications/LVGL/src/others/xml/: lv_xml.c lv_xml_base_types.c lv_xml_component.c
  group LVGL/src/stdlib
    ../../Applications/LVGL/src/stdlib/: lv_mem.c
    ../../Applications/LVGL/src/stdlib/builtin/: lv_mem_core_builtin.c lv_sprintf_builtin.c lv_string_builtin.c lv_tlsf.c
    ../../Applications/LVGL/src/stdlib/clib/: lv_mem_core_clib.c lv_sprintf_clib.c lv_string_clib.c
  group LVGL/src/themes
    ../../Applications/LVGL/src/themes/: lv_theme.c
    ../../Applications/LVGL/src/themes/simple/: lv_theme_simple.c
  group LVGL/src/tick
    ../../Applications/LVGL/src/tick/: lv_tick.c
  group LVGL/src/widgets
    ../../Applications/LVGL/src/widgets/animimage/: lv_animimage.c
    ../../Applications/LVGL/src/widgets/arc/: lv_arc.c
    ../../Applications/LVGL/src/widgets/arclabel/: lv_arclabel.c
    ../../Applications/LVGL/src/widgets/bar/: lv_bar.c
    ../../Applications/LVGL/src/widgets/button/: lv_button.c
    ../../Applications/LVGL/src/widgets/buttonmatrix/: lv_buttonmatrix.c
    ../../Applications/LVGL/src/widgets/calendar/: lv_calendar_chinese.c
    ../../Applications/LVGL/src/widgets/canvas/: lv_canvas.c
    ../../Applications/LVGL/src/widgets/chart/: lv_chart.c
    ../../Applications/LVGL/src/widgets/checkbox/: lv_checkbox.c
    ../../Applications/LVGL/src/widgets/dropdown/: lv_dropdown.c
    ../../Applications/LVGL/src/widgets/image/: lv_image.c
    ../../Applications/LVGL/src/widgets/imagebutton/: lv_imagebutton.c
    ../../Applications/LVGL/src/widgets/keyboard/: lv_keyboard.c
    ../../Applications/LVGL/src/widgets/label/: lv_label.c
    ../../Applications/LVGL/src/widgets/led/: lv_led.c
    ../../Applications/LVGL/src/widgets/line/: lv_line.c
    ../../Applications/LVGL/src/widgets/list/: lv_list.c
    ../../Applications/LVGL/src/widgets/lottie/: lv_lottie.c
    ../../Applications/LVGL/src/widgets/menu/: lv_menu.c
    ../../Applications/LVGL/src/widgets/msgbox/: lv_msgbox.c
    ../../Applications/LVGL/src/widgets/property/: lv_animimage_properties.c lv_dropdown_properties.c lv_image_properties.c lv_label_properties.c lv_obj_properties.c lv_roller_properties.c lv_slider_properties.c lv_style_properties.c lv_textarea_properties.c
    ../../Applications/LVGL/src/widgets/roller/: lv_roller.c
    ../../Applications/LVGL/src/widgets/scale/: lv_scale.c
    ../../Applications/LVGL/src/widgets/slider/: lv_slider.c
    ../../Applications/LVGL/src/widgets/span/: lv_span.c
    ../../Applications/LVGL/src/widgets/spinbox/: lv_spinbox.c
    ../../Applications/LVGL/src/widgets/spinner/: lv_spinner.c
    ../../Applications/LVGL/src/widgets/switch/: lv_switch.c
    ../../Applications/LVGL/src/widgets/table/: lv_table.c
    ../../Applications/LVGL/src/widgets/tabview/: lv_tabview.c
    ../../Applications/LVGL/src/widgets/textarea/: lv_textarea.c
    ../../Applications/LVGL/src/widgets/tileview/: lv_tileview.c
    ../../Applications/LVGL/src/widgets/win/: lv_win.c
  group Drivers
    ../../Drivers/GC9D01/: GC9D01.c
    ../../Drivers/SW6306/: sw6306.c
    ../../Drivers/SD3078/: sd3078.c
    ../../Drivers/SC7A20/: sc7a20.c
    ../../Drivers/Buttons/: buttons.c
    ../../Drivers/WLED/: wled.c
  group Menu
    ../../Applications/menu/: menu.c menu_icons.c menu_pages.c menu_theme.c menu_ui.c
  group services
    ../../Applications/framework/: pm_controller.c pm_device.c pm_device_builtin.c pm_policy.c nvm_store.c pm_sleep_timer.c
  group Algorithm
    ../../Applications/algorithm/: sd3078_algo.c sw6306_algo.c sc7a20_algo.c wled_algo.c
  group Functions
    ../../Applications/functions/: main_screen.c main_icons.c reset.c screen_test.c sos.c gravity_calibrate.c leveler.c dinosaur_game.c dinosaur_icon.c
  group Tasks
    ../../Applications/: ui_task.c button_task.c SW6306_task.c powerdown_task.c load_task.c
  group Documents
    ../../Drivers/SW6306/: readme_SW6306.txt
  group middlewares/freertos
    ../../middlewares/freertos/source/: croutine.c event_groups.c list.c queue.c tasks.c timers.c stream_buffer.c
